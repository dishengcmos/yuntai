# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\SRC;..\SRC\vcp;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\SRC\drv;..\SRC\sensors;..\SRC\cli;..\SRC\calibration;..\SRC\vcp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SRC
    ../SRC/: pid.c computeMotorCommands.c config.c evvgcCF.c fastTrig.c firstOrderFilter.c MargAHRS.c pointingCommands.c stm32_it.c utilities.c
  group DRV
    ../SRC/drv/: drv_cli.c drv_gpio.c drv_i2c.c drv_irq.c drv_pwmMotors.c drv_rc.c drv_system.c drv_timingFunctions.c drv_usart.c ringbuffer.c
  group sensors
    ../SRC/sensors/: hmc5883.c mpu6050.c
  group cli
    ../SRC/cli/: cli.c cliSensor.c
  group calibration
    ../SRC/calibration/: magCalibration.c mpu6050Calibration.c
  group VCP
    ../SRC/vcp/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
